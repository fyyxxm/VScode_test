# Keil uVision project My_H7_Proecct.uvprojx, settings and files
target Radar_Ranging (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: My_H7_Proecct +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32H743xx
  c include: ..\User;..\STM32H7xx_Driver\Include;..\STM32H7xx_Driver\Include\Include;..\STM32H7xx_Driver\Source;..\STM32H7xx_Driver\Source\Source;..\FreeRTOS\FreeRTOS\Include;..\FreeRTOS\FreeRTOS\Portable\Keil;..\FreeRTOS\FreeRTOS\Portable\MemMang;..\FreeRTOS\FreeRTOS\Portable\RVDS\ARM_CM4F;..\FreeRTOS\FreeRTOS\Source;..\DW_Driver\Include;..\DW_Driver\Source;..\FYYXXM_BSP\Include;..\FYYXXM_BSP\Source;..\FYYXXM_APP\Include;..\FYYXXM_APP\Source;..\FYYXXM_Driver\Include;..\FYYXXM_Driver\Source;..\FYYXXM_CallBack\Include;..\FYYXXM_CallBack\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ./: main.c cpu_utils.c
  group STM32H7xx_Driver
    ../STM32H7xx_Driver/Source/Source/: stm32h7xx_it.c system_stm32h7xx.c startup_stm32h743xx.s
    ../STM32H7xx_Driver/Source/: stm32h7xx_ll_dma.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_i2c.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_spi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c
  group FreeRTOS
    ../FreeRTOS/FreeRTOS/Portable/MemMang/: heap_4.c
    ../FreeRTOS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/FreeRTOS/Portable/RVDS/ARM_CM4F/: port.c
  group DW_Driver
    ../DW_Driver/Source/: deca_device.c deca_params_init.c
  group FYYXXM_BSP
    ../FYYXXM_BSP/Include/: bsp.h
    ../FYYXXM_BSP/Source/: bsp_string.s bsp_system_clock.c bsp_spi.c bsp_spi_dwm1000.c bsp_usart.c bsp_gpio.c bsp_delay.c bsp_rng.c bsp_dma.c bsp_exit_interrupt.c bsp_i2c.c bsp_mpu_cache.c bsp_i2c_eeprom_24xx.c bsp_iwdog.c bsp_time.c
  group FYYXXM_APP
    ../FYYXXM_APP/Source/: app_crc.c app_dwm1000.c app_dwm1000_led.c app_filter.c
  group FYYXXM_CallBack
    ../FYYXXM_CallBack/Source/: cb_dw_rx.c
